# Keil uVision project stm32f767.uvprojx, settings and files
target stm32f767 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32f767
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --c99
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;..\User\Inc;..\STemWinLibrary532\Config;..\STemWinLibrary532\OS;..\STemWinLibrary532\inc;..\bmp;..\frame;..\capture
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c fmc.c ltdc.c sdmmc.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group User
    ../User/Src/: gt911.c i2c.c i2c_ns2009.c i2c_touch.c ns2009.c stm32f769i_discovery_sdram.c lcd.c power_on.c
  group STemWin
    ../STemWinLibrary532/Config/: GUIConf.c GUIDRV_Template.c LCDConf.c
    ../STemWinLibrary532/OS/: GUI_X.c GUI_X_Touch_Analog.c
    ../STemWinLibrary532/Lib/: STemWin532_CM7_Keil.lib
  group frame
    ../frame/: frame.c
  group bmp
    ../bmp/: bmp.c
  group font
    ../font/: Fixedsys16.c GUI_CharPEx.c GUI_UC_EncodeNone.c GUI_Font48.c
  group capture
    ../capture/: capture.c
software components: CMSIS:CORE 4.3.0
