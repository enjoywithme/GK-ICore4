# Keil uVision project 1_led.uvprojx, settings and files
target 1_led (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 1_led
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Src/: gpio.c stm32f7xx_it.c main.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc_ex.c
software components: CMSIS:CORE 4.1.0
