# Keil uVision project lwip.uvprojx, settings and files
target lwip (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: lwip
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --c99
  c include: .\include;.\STM32F7xx_HAL_Driver\Inc\Legacy;.\STM32F7xx_HAL_Driver\Inc;.\fatfs\src;.\UCOSII\uC-CPU;.\UCOSII\uC-LIB;.\UCOSII\uCOS-CONFIG;.\UCOSII\uCOS-II;.\UCOSII\UCOS_BSP;.\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;.\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;.\UCOSII\uCOS-II\Source;.\LWIP;.\LWIP\arch;.\LWIP\lwip_app\lwip_comm;.\LWIP\lwip-1.4.1\src\api;.\LWIP\lwip-1.4.1\src\include\ipv4;.\LWIP\lwip-1.4.1\src\include\lwip;.\LWIP\lwip-1.4.1\src\include\netif;.\LWIP\lwip-1.4.1\src\include;.\LWIP\lwip_app\tcp_client_demo;.\LWIP\lwip_app\udp_demo;.\LWIP\lwip_app\web_socket_demo;.\LWIP\lwip_app\modbus_tcp;.\LWIP\lwip_app\tcp_server_demo;.\LWIP\lwip_app\netio;.\LWIP\lwip_app\dns_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group start_up
    ./: startup_stm32f767xx.s
  group main
    ./main/: main.c
  group driver
    ./driver/: led.c usart6.c stm32f769i_eval_sd.c system_clock.c stm32f7xx_it.c system_stm32f7xx.c delay.c sys.c lan8720.c malloc.c crc.c adc.c
  group fwlib
    ./STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_eth.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group lwip_app
    ./LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ./LWIP/lwip_app/netio/: netio.c
    ./LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
  group ucosii
    ./UCOSII/uC-CPU/: cpu_core.c
    ./UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ./UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ./UCOSII/UCOS_BSP/: bsp.c cpu_bsp.c
    ./UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_cpu.h
    ./UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./UCOSII/uCOS-CONFIG/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group lwip
    ./LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c err.c
    ./LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c netif.c
    ./LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ./LWIP/arch/: sys_arch.c
software components: CMSIS:CORE 4.3.0
